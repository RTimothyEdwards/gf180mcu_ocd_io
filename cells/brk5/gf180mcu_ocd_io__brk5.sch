v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {gf180mcu_ocd_io__brk5
power bus breaker} -140 -250 0 0 0.4 0.4 {}
N -120 -130 -100 -130 {lab=VSS}
C {iopin.sym} -120 -130 0 1 {name=p4 lab=VSS}
C {noconn.sym} -100 -130 0 1 {name=l2}
